# Keil uVision project APP_3.uvproj, settings and files
target APP_3 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP_3 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\StdPeriph_Driver\inc;..\CMSIS;..\Utilities\LED;..\Utilities\KEY;..\Utilities\IR;..\Utilities\TIMER;..\Utilities\USART;..\Utilities\DCMotor;..\Utilities\Remote;..\Utilities\APP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c
  group RVMDK
    ../RVMDK/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Utilities
    ../Utilities/LED/: led.c
    ../Utilities/KEY/: key.c
    ../Utilities/IR/: ir.c
    ../Utilities/TIMER/: timer.c
    ../Utilities/USART/: usart.c
    ../Utilities/DCMotor/: DCMotor.c
    ../Utilities/Remote/: remote.c
    ../Utilities/APP/: app.c
